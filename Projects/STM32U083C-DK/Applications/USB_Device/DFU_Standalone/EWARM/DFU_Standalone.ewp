# IAR project DFU_Standalone.ewp, settings and files
configuration DFU_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U083xx; USE_FULL_LL_DRIVER; USBPDCORE_LIB_NO_PD; USBPD_TYPE_STATE_MACHINE; USBPD_PORT_COUNT=1; _SNK
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\..\..\..\..\..\Drivers\BSP\STM32U083C-DK; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc; ..\USB_Device\App; ..\USB_Device\Target; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32U0XX\inc; ..\USB-PD\Target; ..\USB-PD
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Standalone.hex
  ILINK.IlinkOutputFile: HID_Standalone.out
  ILINK.IlinkIcfFile: STM32U083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u0xx_hal_msp.c stm32u0xx_it.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_flash.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U083C-DK
    ../../../../../../Drivers/BSP/STM32U083C-DK/: stm32u083c_discovery.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_i2c.c stm32u0xx_hal_lptim.c stm32u0xx_hal_pcd.c stm32u0xx_hal_pcd_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_ll_dma.c stm32u0xx_ll_gpio.c stm32u0xx_ll_usb.c
  group Middleware/USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
